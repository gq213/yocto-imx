
UBOOT_SRC = "git://github.com/gq213/uboot-imx.git;protocol=https"
SRCBRANCH = "master"
SRCREV = "f76644f8470fdba97c9543feee71012928ca6659"
