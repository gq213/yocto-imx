FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0002-add-flash_gq.patch \
"
