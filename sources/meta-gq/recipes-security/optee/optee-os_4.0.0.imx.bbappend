FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://20-ddr-size-4G.patch \
"

