
KERNEL_SRC = "git://github.com/gq213/linux-imx.git;protocol=https;branch=${SRCBRANCH}"
SRCBRANCH = "master"
SRCREV = "4758ad2c473c23f0365aafa7ba1e8d4f82ba8520"
