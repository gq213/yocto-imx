
KERNEL_SRC = "git://github.com/gq213/linux-imx.git;protocol=https;branch=${SRCBRANCH}"
SRCBRANCH = "master"
SRCREV = "1bbe126672e5ca617ffdac033a7f7a90e10b9086"
