FILESEXTRAPATHS:prepend := "${THISDIR}/imx219:"

SRC_URI += "file://0001-isp-vvcam-add-imx219.patch \
			file://0002-imx219-auto-focus.patch \
"
