FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

IMX_PATCH += "file://0020-add-conf-for-imx-tlv320aic3106-sound-card.patch \
"
